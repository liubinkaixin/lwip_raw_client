# Keil uVision project STM32F407_LWIP.uvproj, settings and files
target STM32F407_LWIP (5040049::V5.04 update 1 (build 49)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: LWIP_RAW_client_dhcp +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS
  c include: ..\CORE;..\USER;..\FWLIB\inc;..\HARDWARE\inc;..\USB\USB_APP;..\USB\STM32_USB_OTG_Driver\inc;..\FATFS;..\FATFS\src;..\FATFS\src\option;..\MALLOC;..\USB\STM32_USB_HOST_Library\Class\MSC\inc;..\USB\STM32_USB_HOST_Library\Core\inc;..\LWip1.4.1;..\LWip1.4.1\src\include;..\LWip1.4.1\src\include\ipv4;..\LWip1.4.1\src\include\netif;..\ETHLIB\inc;..\LWipAPP\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c CriticalSeg.c CriticalSeg.h
  group HARDWARE
    ../HARDWARE/scr/: delay.c usart1.c 8720.c timer3.c
    ./: retarget.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s stm32f4xx_it.c system_stm32f4xx.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_fsmc.c
  group ETHLIB
    ../ETHLIB/src/: stm32f4x7_eth.c
  group lwIP-NETIF
    ../LWip1.4.1/src/netif/: ethernetif.c etharp.c
  group lwIP-API
    ../LWip1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwIP-CORE
    ../LWip1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../LWip1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group lwIP-ARCH
    ../LWip1.4.1/arch/: sys_arch.c
  group lwIP-APP
    ../LWipAPP/scr/: tcpclient.c
  group DOC
    ../: readme.txt
